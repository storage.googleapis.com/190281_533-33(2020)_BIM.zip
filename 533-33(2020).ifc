Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-07-14T17:56:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 14 17:56:44 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{174F33C6-DB8A-4D4F-AEBF-88B2ED1AECE6}\ifc * Database version: 5507 * Database creation date: Tue Jul 14 17:56:41 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 14 17:56:42 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 14 17:56:42 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 533-33 Hand shower set, 533-33(2020):533-33 Hand shower set:319151
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 58.4 mm; NominalHeight: 345.1 mm; NominalWidth: 95.9 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 533-33(2020); ConvergoRefNr: 0087-2006-0067-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 10/07/2020
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150097577; EN Standard: EN 1112; LVI Number: 6510265
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/533-33; Dimension Drawing URL: http://static.oras.com/dimdrw/533-33; FDV Document URL: http://www.oras.com/datasheet/533-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/533-33; Group: HandShower; Manufacturer: Oras; Model: 533 Hand shower set; Name_en: 533-33 Hand shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; PackageDimensions: 300.0 x 200.0 x 30.0; Package external Dimensions: 300 x 200 x 30; Package Weight: 0.460 kg; Product Code: 533-33; Product Datasheet: http://www.oras.com/datasheet/533-33/en; Product data url: 1; Product Family: Oras Apollo; Product Image URL: http://static.oras.com/image/533-33; Product URL: http://static.oras.com/533-33; Technical DataSheet URL: http://www.oras.com/datasheet/533-33/en; Type Name: 533-33 Hand shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa: 0.00105944 m3/s; Hand Shower Size: Ø 95 mm; Installation and Maintenance: http://static.oras.com/manual/533-33; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Shower holder;Hand shower;Shower Hose (1500 mm);; Shower Spray: Intense; Shower Spray Number: 1Spray
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 533-33(2020); Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 533-33; Name: 533-33 Hand shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 95x60x345 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 533-33; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 533-33 Hand shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0588368 m2; Volume: 0.00193207 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 533-33(2020): 533-33 Hand shower set; Family and Type: 533-33(2020): 533-33 Hand shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 533-33(2020): 533-33 Hand shower set; Type Id: 533-33(2020): 533-33 Hand shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
